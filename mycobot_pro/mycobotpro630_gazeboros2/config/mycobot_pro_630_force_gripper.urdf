Commit message: perf: optimize motion logic and functionality

File: mycobot_pro/mycobotpro630_gazeboros2/config/mycobot_pro_630_force_gripper.urdf (robot description, URDF)
Before this commit: robot firefighter, 8 links, 7 joints
Joints:
- joint joint6_to_joint5: axis -1 0 0 -> 1 0 0
